# Keil uVision project BLDCproject.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: BLDCproject +hex
  c flags: Optimize=4 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./src/: Initialisation.c main.c Interrupt.c flash.c Flash operation.c NEC IR.c PWM.c I2C.C
